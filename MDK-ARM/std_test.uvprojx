# Keil uVision project std_test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ac5)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: std_test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\user;..\Library;..\start;..\MDK-ARM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start
    ../start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group Library
    ../Library/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group user
    ../user/: main.c stm32f10x_it.c font.c oled.c font.h oled.h stm32f10x_conf.h stm32f10x_it.h
    ./: Delay.h Delay.c
